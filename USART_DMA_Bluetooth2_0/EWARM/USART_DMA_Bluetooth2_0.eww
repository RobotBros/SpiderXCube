<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USART_DMA_Bluetooth2_0.ewp</path>
  </project>
  <batchBuild/>
</workspace>


