# IAR project USART_DMA_Bluetooth2_0.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: VECT_TAB_SRAM; STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\STM32F10x_FWLib\inc; ..\..\CMSIS\Include; ..\..\BSP\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USART_DMA_Bluetooth2_0.srec
  ILINK.IlinkOutputFile: USART_DMA_Bluetooth2_0.out
  ILINK.IlinkIcfFile: stm32f103xC-RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ROM (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: stm32f103xC-ROM.icf
  group BSP
    ../../BSP/Src/: bt2.c spiderx_bsp.c
    ../../BSP/Inc/: bt2.h spiderx_bsp.h
  group Doc
    ../: README.txt
  group EWARM
    ../../USART_IT_Bluetooth2_0/EWARM/: startup_stm32f10x_hd_vl.s
  group STM32F10x_FWLib
    ../../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../Src/: main.c stm32f1xx_it.c
    ../../BSP/Src/: system_stm32f10x.c
