# Keil uVision project SimpleControlBLE.uvprojx, settings and files
target RAM (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SimpleControlBLE
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: VECT_TAB_SRAM, STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Inc;..\..\STM32F10x_FWLib\inc;..\..\CMSIS\Include;..\..\BSP\Inc
  memory RVCT4: ROM 0x20000000 size 0x7000
  memory RVCT9: RAM 0x20007000 size 0x5000
  group BSP
    ../../BSP/Src/: bt4.c flash.c power.c servo.c spiderx_bsp.c system_stm32f10x.c
    ../../BSP/Inc/: bt4.h flash.h power.h servo.h spiderx_bsp.h stm32f10x.h
  group Doc
    ../: README.txt
  group MDK
    ./: startup_stm32f10x_hd.s
  group STM32F10x_FWLib
    ../../STM32F10x_FWLib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../Inc/: main.h stm32f1xx_it.h stm32f10x_conf.h system.h system_stm32f10x.h
    ../Src/: main.c stm32f1xx_it.c system.c
target ROM (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: as above
  output: SimpleControlBLE
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
