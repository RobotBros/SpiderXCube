# IAR project SimpleControlBLE.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\STM32F10x_FWLib\inc; ..\..\CMSIS\Include; ..\..\BSP\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: SimpleControlBLE.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ROM (ARM, debug)
  as the first configuration, except:
  group BSP
    ../../BSP/Src/: bt2.c bt4.c flash.c power.c servo.c spiderx_bsp.c system_stm32f10x.c
    ../../BSP/Inc/: bt2.h bt4.h flash.h power.h servo.h spiderx_bsp.h stm32f10x.h
  group Doc
    ../: README.txt
  group EWARM
    ./: startup_stm32f10x_hd_vl.s
  group STM32F10x_FWLib
    ../../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../Src/: main.c stm32f1xx_it.c system.c
    ../Inc/: main.h SpiderNANOConfig.h stm32f10x_conf.h stm32f1xx_it.h system.h system_stm32f10x.h
