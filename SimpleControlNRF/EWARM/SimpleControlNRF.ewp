# IAR project SimpleControlNRF.ewp, settings and files
configuration ROM (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\HARDWARE\LED; ..\SYSTEM\delay; ..\SYSTEM\sys; ..\SYSTEM\usart; ..\USER; ..\STM32F10x_FWLib\inc; ..\HARDWARE\KEY; ..\HARDWARE\TIMER; ..\HARDWARE\ACTION; ..\HARDWARE\ADC; ..\HARDWARE\BEEP; ..\HARDWARE\NRF24L01; ..\HARDWARE\SPI; ..\HARDWARE\EXTI; $PROJ_DIR$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: SimpleControlNRF.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ./: handler.h startup_stm32f10x_hd_vl.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/NRF24L01/: 24l01.c 24l01.h
    ../HARDWARE/ACTION/: action.c action.h
    ../HARDWARE/ADC/: adc.c adc.h
    ../HARDWARE/BEEP/: beep.c beep.h
    ../HARDWARE/EXTI/: exti.c exti.h
    ../HARDWARE/LED/: led.c led.h
    ../HARDWARE/SPI/: spi.c spi.h
    ../HARDWARE/TIMER/: timer.c timer.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/sys/: sys.c sys.h
    ../SYSTEM/usart/: usart.c usart.h
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
