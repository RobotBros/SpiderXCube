# Keil uVision project USART_DMA_Bluetooth4_0.uvprojx, settings and files
target RAM (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART_DMA_Bluetooth4_0
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD USE_STDPERIPH_DRIVER VECT_TAB_RAM
  c include: ..\Inc;..\..\STM32F10x_FWLib\inc;..\..\CMSIS\Include;..\..\BSP\Inc
  memory RVCT4: ROM 0x20000000 size 0x5000
  memory RVCT9: RAM 0x20005000 size 0x7000
  group BSP
    ../../BSP/Src/: bt4.c spiderx_bsp.c system_stm32f10x.c
  group Doc
    ../: README.txt
  group STM32F10x_FWLib
    ../../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group MDK
    ./: startup_stm32f10x_hd.s
  group User
    ../Src/: main.c stm32f1xx_it.c
target ROM (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: as above
  output: USART_DMA_Bluetooth4_0
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD USE_STDPERIPH_DRIVER
  c include: ..\Inc;..\..\STM32F10x_FWLib\inc;..\..\CMSIS\Include;..\..\BSP\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
